# Keil uVision project 1.8TFT.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(24000000)
  output: 18inch +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: S6D0144_8bit.c
