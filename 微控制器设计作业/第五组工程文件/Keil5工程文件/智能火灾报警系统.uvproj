# Keil uVision project 智能火灾报警系统.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 智能火灾报警系统 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c iic.c iic.h key.c key.h led.c led.h onewire.c onewire.h LCD1602.h LCD1602.c
