	ORG 0000H
INIT:
	LCALL TIMER0_INIT
	LJMP MAIN
	ORG 000BH
	LJMP TIMER0_ISR
	ORG 0030H
MAIN:
	LCALL KEY_PRO
	LCALL SEG_PRO
	LCALL LED_PRO
	SJMP $

LED_DISPLAY:

KEY_PRO:
	


LED_PRO:
	

SEG_PRO:
	
TIMER0_ISR:
	INC R0
	CJNE R0, #200,SS
	MOV R0,#00H
	CPL P1.0
SS:
	RETI

TIMER0_INIT:				;1毫秒@11.0592MHz
	//MOV		AUXR, #00H		;定时器时钟1T模式
	ANL		TMOD,#0F0H		;设置定时器模式
	MOV		TL0,#0CDH		;设置定时初始值
	MOV		TH0,#0D4H		;设置定时初始值
	CLR		TF0				;清除TF0标志
	SETB	TR0				;定时器0开始计时
	SETB	ET0				;使能定时器0中断
	SETB    EA
	RET

END