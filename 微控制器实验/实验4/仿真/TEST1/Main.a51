	ORG 0000H
	LJMP MAIN
	ORG 0030H
MAIN:
	MOV TMOD,#06H
	MOV TL0,#0FFH
	MOV TH0,#0FFH
	SETB TR0
LOOP1:
	JBC TF0,T0S
	SJMP LOOP1
T0S:
	CLR TR0
	MOV TMOD,#02H
	MOV TL0,#06H
	MOV TH0,#06H
	CLR P1.0
	SETB TR0
LOOP2:
	JBC TF0,T0S1
	SJMP LOOP2
T0S1:
	SETB P1.0
	CLR TR0
	LJMP MAIN
END