	ORG 0000H
	LJMP MAIN
	ORG 001BH
	LJMP TIME
	ORG 0030H

MAIN:
	MOV SP,#60H
	MOV TMOD ,#60H ;0110 0000
	MOV TH1, #0FDH
	MOV TL1, #0FDH
	MOV IE ,#88H
	SETB TR1
LOOP:
	  AJMP	LOOP			;等待循环
TIME:
	MOV A, #0FEH
	MOV R1,#08H
	LCALL LED
	MOV P1,#0FFH
	RETI
LED:
	MOV P1,A
	RL A
	LCALL DELAY100MS
	DJNZ R1,LED
	RET
DELAY100MS:			;@12.000MHz
	PUSH	30H
	PUSH	31H
	MOV		30H,#195
	MOV		31H,#133
NEXT:
	DJNZ	31H,NEXT
	DJNZ	30H,NEXT
	POP		31H
	POP		30H
	RET
END