	ORG 0000H

INIT:
	MOV R0, #10;设置循环次数
	MOV R1, #00H;偏移量
	MOV DPTR, #LEDTABLE

MAIN:
	MOV   A, R1;将偏移量赋值给A
	MOVC A, @A + DPTR
	MOV P1, A;把A赋值给P1
	LCALL DELAY500MS
	INC R1;R2加1
	DJNZ R0, MAIN;减1至0
	SJMP INIT
	
DELAY500MS:			;@12.000MHz
	PUSH	30H
	PUSH	31H
	PUSH	32H
	MOV		30H,#4
	MOV		31H,#205
	MOV		32H,#180
NEXT:
	DJNZ	32H,NEXT
	DJNZ	31H,NEXT
	DJNZ	30H,NEXT
	POP		32H
	POP		31H
	POP		30H
	RET

LEDTABLE:
	DB 0C0H,0F9H,0A4H,0B0H,99H,92H,82H,0F8H,80H,90H

END